PACKAGECONFIG:append = " zstd"